# Keil uVision project SpaceInvaders.uvprojx, settings and files
target SpaceInvaders (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SpaceInvaders
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..;C:\Keil\TExaSware
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s random.s SpaceInvaders.c ADC.c DAC.c Switch.c Sound.c Timer0.c Accelerometer.c PLL.c ST7735.c diskio.c ff.c Bluetooth.c Expansion_Card.c
software components: CMSIS:CORE 5.0.1
